# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\6-1 矩阵键盘
  group Source Group 1
    ./: STARTUP.A51 MatrixKeyboard.c MatrixKeyboard.h main.c
    ../5-2 LCD1602调试/: LCD1602.c LCD1602.h
    ../5-1 模块化编程/: Delay.c Delay.h
